<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\pca10056\blank\iar\nrf52840_ws2812b.ewp</path>
    </project>
    <batchBuild />
</workspace>
